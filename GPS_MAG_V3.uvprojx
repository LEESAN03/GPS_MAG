# Keil uVision project GPS_MAG_V3.uvprojx, settings and files
target GPS_MAG_V3 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPS_MAG_V3 +hex
  AfterMake: fromelf.exe --bin -o ./output/GPS_MAG_V3.bin ./output/GPS_MAG_V3.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\StartUp;.\User_Src;.\Lib\inc;.\HardWareDriver;.\HardWareDriver\QMC5883L;.\HardWareDriver\UART2;.\HardWareDriver\UART1;.\HardWareDriver\EEPROM;.\HardWareDriver\TIMER_CONFIG;.\HardWareDriver\GPS;.\HardWareDriver\IOI2C;.\HardWareDriver\CAN_TO_IMU;.\Lib\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./StartUp/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
    ./Lib/src/: stm32f10x_can.c
  group HardWareDriver
    ./HardWareDriver/: delay.c compute.c chipFlash.c
    ./HardWareDriver/UART2/: UART2.c
    ./HardWareDriver/TIMER_CONFIG/: TIMER_CONFIG.c
    ./HardWareDriver/UART1/: UART1.c
    ./HardWareDriver/IOI2C/: IOI2C.c
    ./HardWareDriver/GPS/: GPS.c
    ./HardWareDriver/QMC5883L/: QMC5883L.c
  group User_Src
    ./User_Src/: main.c stm32f10x_it.c
    ./HardWareDriver/CAN_TO_IMU/: can_to_imu.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_dma.c
software components: CMSIS:CORE 5.1.1
